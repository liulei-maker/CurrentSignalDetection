# Keil uVision project CapacitanceMeasure.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CapacitanceMeasure +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USMART;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\DATASAMPLING;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\WDG;..\HARDWARE\IIC;..\HARDWARE\FM25V02;..\HARDWARE\FDC2X14;..\HARDWARE\ADS1118;..\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/DATASAMPLING/: Data_sampling.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/FM25V02/: FM25V02.c
    ../HARDWARE/FDC2X14/: FDC2X14.c
    ../HARDWARE/ADS1118/: ads1118.c
    ../HARDWARE/OLED/: oled.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
